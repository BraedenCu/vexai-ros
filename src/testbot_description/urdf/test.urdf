Commit message: commiting before attempting to fix more stuff

File: src/testbot_description/urdf/test.urdf (robot description, URDF)
Before this commit: robot visual, 16 links, 15 joints
Joints:
- joint right_back_wheel_joint: child right_back_wheel -> right_b0254ack_wheel
